options:
  parameters:
    generate_options: qt_gui
    id: phase_uhd
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '50000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2500000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: phase_0.8m_52.5MHz.dat
    type: float
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 5*samp_rate
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '4'
    min: '-4'
    name: '"src 0"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '4'
    min: '-4'
    name: '"src 1"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '4'
    min: '-4'
    name: '"diff"'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: samp_rate/2
    bw1: samp_rate/2
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: '"serial=326F639"'
    gain0: '0.3'
    gain1: '0'
    gain_type0: normalized
    gain_type1: normalized
    lo_export1: 'False'
    lo_source1: internal
    nchan: '2'
    samp_rate: samp_rate
    show_lo_controls: 'True'
    stream_args: num send f rames = 1024
    stream_chans: '[0,1]'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: samp_rate/2
    bw1: samp_rate/2
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: '"serial=326F639"'
    gain0: '1'
    gain1: '1'
    gain_type0: normalized
    gain_type1: normalized
    lo_export1: 'False'
    lo_source1: internal
    nchan: '2'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate
    show_lo_controls: 'True'
    stream_args: num send f rames = 1024
    stream_chans: '[0,1]'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '1']
- [blocks_complex_to_arg_1, '0', blocks_skiphead_0, '0']
- [blocks_complex_to_arg_1, '0', qtgui_number_sink_1, '0']
- [blocks_complex_to_arg_1_0, '0', qtgui_number_sink_0_1, '0']
- [blocks_complex_to_arg_1_0_0, '0', qtgui_number_sink_0_1_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_1, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_throttle_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [uhd_usrp_source_0_0, '0', blocks_complex_to_arg_1_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_throttle_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_complex_to_arg_1_0_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_throttle_1, '0']
- [uhd_usrp_source_0_0, '1', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0-rc1
