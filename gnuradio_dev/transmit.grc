options:
  parameters:
    generate_options: qt_gui
    id: fmcw_sim
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '1000000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gprlab/Desktop/gpr/gnu_log/chirp_stored20
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_vco_f_0_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 3140000*2
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: samp_rate/2
    bw1: samp_rate/2
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: '"serial=326F639"'
    gain0: '0.5'
    gain1: '0'
    gain_type0: normalized
    gain_type1: normalized
    lo_export1: 'False'
    lo_source1: internal
    nchan: '2'
    samp_rate: samp_rate
    show_lo_controls: 'True'
    stream_args: num send f rames = 1024
    stream_chans: '[0,1]'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: samp_rate/2
    bw1: samp_rate/2
    center_freq0: center_freq
    center_freq1: center_freq
    dev_addr: '"serial=326F639"'
    gain0: '0.5'
    gain1: '0.5'
    gain_type0: normalized
    gain_type1: normalized
    lo_export1: 'False'
    lo_source1: internal
    nchan: '2'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate
    show_lo_controls: 'True'
    stream_args: num send f rames = 1024
    stream_chans: '[0,1]'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_vco_f_0_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0_0, '1']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0_0, '1']
- [blocks_vco_f_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_vco_f_0_0, '0', blocks_float_to_complex_0, '1']
- [uhd_usrp_source_0_0_0, '0', qtgui_time_sink_x_2, '0']
- [uhd_usrp_source_0_0_0, '1', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0-rc1
